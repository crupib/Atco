# IAR project MCU16.ewp, settings and files
configuration MCU16 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Inc; C:/Users/atcop/STM32Cube/Repository/STM32Cube_FW_F7_V1.3.0/Drivers/STM32F7xx_HAL_Driver/Inc; C:/Users/atcop/STM32Cube/Repository/STM32Cube_FW_F7_V1.3.0/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; C:/Users/atcop/STM32Cube/Repository/STM32Cube_FW_F7_V1.3.0/Drivers/CMSIS/Include; C:/Users/atcop/STM32Cube/Repository/STM32Cube_FW_F7_V1.3.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: MCU16.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c main.c tim.c gpio.c usart.c adc.c
  group Application/EWARM
    ./: 
    C:/Users/atcop/STM32Cube/Repository/STM32Cube_FW_F7_V1.3.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
  group Drivers
    ./: 
  group Drivers/STM32F7xx_HAL_Driver
    ./: 
    C:/Users/atcop/STM32Cube/Repository/STM32Cube_FW_F7_V1.3.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_rtc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc.c
  group Drivers/CMSIS
    ./: 
    C:/Users/atcop/STM32Cube/Repository/STM32Cube_FW_F7_V1.3.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
